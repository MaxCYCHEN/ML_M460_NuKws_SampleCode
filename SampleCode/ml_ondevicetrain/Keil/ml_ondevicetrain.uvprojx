# Keil uVision project ml_ondevicetrain.uvprojx, settings and files
target ml_ondevicetrain (6160000::V6.16::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: ml_ondevicetrain
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: TF_LITE_STATIC_MEMORY, ARM_MATH_CM4=1, __FPU_PRESENT=1UL
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\ThirdParty;..\..\..\Library\StdDriver\inc;..\Sensor;..\ili9341;..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group Source
    ../: main.cpp
  group Library
    ../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c gpio.c pdma.c timer.c spi.c retarget.c
    ../../../Library/CMSIS/Include/: cmsis-nn.lib
    ../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Sensor
    ../Sensor/: MPU6500.c
  group SVM
    ../: svm.cpp svm-train.c svm-predict.c svm_feature.c svm-scale.c
  group ili9341
    ../ili9341/: fonts.c ili9341.c
    ../: spi_panel.c
