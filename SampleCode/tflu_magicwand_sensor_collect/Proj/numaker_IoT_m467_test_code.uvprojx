# Keil uVision project numaker_IoT_m467_test_code.uvprojx, settings and files
target numaker_IoT_m467_test_code (6160000::V6.16::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: numaker_IoT_m467_test_code +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CMSIS;..\CMSIS\Include;..\StdDriver\inc;..\User\inc;..\FatFs\source;..\drv_emac
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../CMSIS/: system_m460.c startup_m460.s
  group StdDriver
    ../StdDriver/src/: clk.c sys.c uart.c retarget.c gpio.c hbi.c usbd.c i2c.c i2s.c hsusbd.c sdh.c pdma.c canfd.c timer.c qspi.c
  group User
    ../User/: main.c spi_flash.c spi_flash.h hyperram.c hyperram.h sound.c audio.c audio.h fsusb_descriptors.c fsusb_mouse.c fsusb_mouse.h hsusb_descriptors.c hsusb_mouse.c hsusb_mouse.h diskio.c sdglue.c canfd_test.c canfd_test.h btn.c btn.h MPU6500.c WiFi.c esp8266.c NCT7717.c
  group FatFs
    ../FatFs/source/: ff.c
  group drv_emac
    ../drv_emac/: synopGMAC_Dev.c synopGMAC_Dev.h synopGMAC_network_interface.c synopGMAC_network_interface.h synopGMAC_plat.h
